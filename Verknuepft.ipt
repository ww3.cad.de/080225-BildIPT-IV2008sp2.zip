# Autodesk Inventor part: Verknuepft
## iProperties
Created: 2008-02
Part Number: Verknuepft
Document SubType Name: Modeling
Designer: mp
Density: 1 g/cm^3
Author: mp
## Feature names
1. Extrusion1
